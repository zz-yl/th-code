# Keil uVision project thp.uvprojx, settings and files
target thp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: thp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER
  c include: ..\..\app\inc;..\..\bsp\cmsis;..\..\bsp\core;..\..\bsp\driver\inc;..\..\bsp\STM32H7xx_HAL_Driver\inc;..\..\public\inc;..\..\test\inc;..\..\system\inc;..\..\system\freertos\include;..\..\system\freertos\portable\RVDS\ARM_CM7\r0p1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group app
    ../../app/src/: main.c task_cfg.c sys_state_machine.c motor_state_machine.c motor.c sys_calibrate.c thp_cfg.c control.c memory.c sys_alarm.c sys_check.c comm.c comm_cmd.c comm_msg.c
    ../../app/inc/: comm_protocol.h
  group system
    ../../system/src/: state_machine.c driver.c device_register.c device_core.c device_data.c device_io.c interp_table.c
  group bsp/driver
    ../../bsp/driver/src/: bsp_init.c bsp_io.c bsp_sys.c bsp_mpu.c bsp_timer.c bsp_usart.c bsp_spi.c bsp_qspi.c bsp_ads131m0x.c bsp_ads131m08.c bsp_i2c.c bsp_motor.c bsp_encoder.c bsp_cfg.c
  group public
    ../../public/src/: data_queue.c data_algorithm.c pid.c crc_check.c
  group test
    ../../test/src/: test.c
  group bsp/core
    ../../bsp/core/: stm32h7xx_it.c
  group bsp/cmsis
    ../../bsp/cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h system_stm32h7xx.c
  group bsp/STM32H7xx_HAL_Driver
    ../../bsp/STM32H7xx_HAL_Driver/src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c
  group system/freertos_core
    ../../system/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group system/freertos_port
    ../../system/freertos/portable/MemMang/: heap_4.c
    ../../system/freertos/portable/RVDS/ARM_CM7/r0p1/: port.c
  group startup
    ../../bsp/cmsis/: startup_stm32h743xx.s
