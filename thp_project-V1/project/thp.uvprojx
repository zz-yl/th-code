# Keil uVision project thp.uvprojx, settings and files
target thp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: thp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\app\inc;..\bsp\driver\inc;..\test\inc;..\public\inc;..\bsp\core;..\bsp\STM32F4xx_StdPeriph_Driver\inc;..\ucos_iii\uc_cpu;..\ucos_iii\uc_cpu\ARM-Cortex-M4;..\ucos_iii\uc_lib;..\ucos_iii\ucos_bsp;..\ucos_iii\ucos_config;..\ucos_iii\ucos_iii\Ports\ARM-Cortex-M4;..\ucos_iii\ucos_iii\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/src/: main.c task_cfg.c control.c motor.c device.c interp_table.c comm.c comm_cmd.c comm_msg.c memory.c sys_cfg.c
    ../app/inc/: comm_protocol.h
  group bsp
    ../bsp/driver/src/: bsp_init.c bsp_delay.c bsp_io.c bsp_timer.c bsp_usart.c bsp_spi.c bsp_ads131m0x.c bsp_ads131m08.c bsp_stmflash.c bsp_cfg.c
  group test
    ../test/src/: test.c
  group public
    ../public/src/: data_algorithm.c pid.c queue.c crc_check.c
  group core
    ../bsp/core/: stm32f4xx_it.c system_stm32f4xx.c
  group startup
    ../bsp/core/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../bsp/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ucosiii_bsp
    ../ucos_iii/ucos_bsp/: bsp.c
  group ucosiii_cpu
    ../ucos_iii/uc_cpu/ARM-Cortex-M4/: cpu_c.c cpu_a.asm
    ../ucos_iii/uc_cpu/: cpu_core.c
  group ucosiii_lib
    ../ucos_iii/uc_lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucos_iii/uc_lib/Ports/ARM-Cortex-M4/: lib_mem_a.asm
  group ucosiii_core
    ../ucos_iii/ucos_iii/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucosiii_port
    ../ucos_iii/ucos_iii/Ports/ARM-Cortex-M4/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ucosiii_config
    ../ucos_iii/ucos_config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
