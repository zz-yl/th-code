# Keil uVision project breath.uvprojx, settings and files
target breath (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431CBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: breath +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L431xx,USE_HAL_DRIVER
  c include: ..\..\app\inc;..\..\bsp\cmsis;..\..\bsp\core;..\..\bsp\driver\inc;..\..\bsp\STM32L4xx_HAL_Driver\inc;..\..\public\inc;..\..\test\inc;..\..\system\inc;..\..\system\freertos\include;..\..\system\freertos\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group app
    ../../app/src/: main.c task_cfg.c comm.c thb_cfg.c motor.c valve.c sys_calibrate.c
  group system
    ../../system/src/: device.c interp_table.c
  group bsp/driver
    ../../bsp/driver/src/: bsp_init.c bsp_io.c bsp_timer.c bsp_i2c.c bsp_i2c_soft.c bsp_spi.c bsp_usart.c bsp_sdp3x.c bsp_sfm3300.c bsp_wpas13.c bsp_sys.c bsp_cfg.c
  group public
    ../../public/src/: data_queue.c data_algorithm.c pid.c crc_check.c
  group test
    ../../test/src/: test.c
  group bsp/core
    ../../bsp/core/: stm32l4xx_it.c system_stm32l4xx.c
  group bsp/cmsis
    ../../bsp/cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm4.h stm32l4xx.h stm32l431xx.h
  group STM32L4xx_HAL_Driver
    ../../bsp/STM32L4xx_HAL_Driver/src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c
  group system/freertos_core
    ../../system/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group system/freertos_port
    ../../system/freertos/portable/MemMang/: heap_4.c
    ../../system/freertos/portable/RVDS/ARM_CM4F/: port.c
  group startup
    ../../bsp/cmsis/: startup_stm32l431xx.s
